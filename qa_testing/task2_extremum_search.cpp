/**
 * Дисципліна: Основи тестування програмного забезпечення
 * Практична робота № 2: Завдання 2
 * Тема: Тестування алгоритму пошуку мінімального та максимального елемента масиву
 * Виконавець: студент групи аІк43 ТАРАС Вадим
 * Викладач: ТКАЧУК А.В.
 * 
 * Еталонна перевірена реалізація (Варіант C).
 * Успішно проходить усі три обов'язкові тестові набори:
 * - Тест 1 (додатні числа): n=5, {3, 8, 2, 10, 5} -> Min=2, Max=10
 * - Тест 2 (від'ємні числа): n=4, {-5, -2, -10, -1} -> Min=-10, Max=-1
 * - Тест 3 (одноелементний граничний масив): n=1, {7} -> Min=7, Max=7
 */

#include <iostream>
#include <vector>

using namespace std;

int main()
{
    int n;
    cout << "Введіть кількість елементів n: ";
    if (!(cin >> n) || n <= 0) {
        cerr << "Помилка: кількість елементів має бути додатною." << endl;
        return 1;
    }

    int a[100];
    cout << "Введіть " << n << " цілих чисел через пробіл: ";
    for (int i = 0; i < n; i++) {
        cin >> a[i];
    }

    // Ініціалізація першим реальним елементом масиву
    // Запобігає дефекту нульової ініціалізації (Bug A)
    int minValue = a[0];
    int maxValue = a[0];

    // Цикл від індексу 1 до n - 1 (перший елемент вже враховано)
    for (int i = 1; i < n; i++)
    {
        if (a[i] < minValue)
            minValue = a[i];

        if (a[i] > maxValue)
            maxValue = a[i];
    }

    cout << "Min = " << minValue << endl;
    cout << "Max = " << maxValue << endl;

    return 0;
}
